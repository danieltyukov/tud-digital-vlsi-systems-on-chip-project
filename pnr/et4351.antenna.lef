

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO et4351 
  PIN clk 
<<<<<<< Updated upstream
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3152 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4472 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 35.8017 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 163.973 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.668946 LAYER Via4 ;
  END clk
  PIN resetn 
    ANTENNAPARTIALMETALAREA 2.7252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2634 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.023175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 143.31 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 649.087 LAYER Metal3 ;
=======
    ANTENNAPARTIALMETALAREA 2.7724 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4758 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.2 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 115.069 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.442735 LAYER Via3 ;
  END clk
  PIN resetn 
    ANTENNAPARTIALMETALAREA 2.7732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4794 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.023175 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 126.291 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 572.505 LAYER Metal3 ;
>>>>>>> Stashed changes
    ANTENNAMAXCUTCAR 2.01079 LAYER Via3 ;
  END resetn
  PIN ser_tx 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
<<<<<<< Updated upstream
    ANTENNAPARTIALMETALAREA 2.8636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.915 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.7851 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 115.481 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.25869 LAYER Via3 ;
  END ser_tx
  PIN ser_rx 
    ANTENNAPARTIALMETALAREA 3.0536 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.77 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 44.0436 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 199.88 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.403704 LAYER Via3 ;
  END ser_rx
  PIN flash_csb 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.8676 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9042 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.6276 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 110.153 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.25783 LAYER Via3 ;
=======
    ANTENNAPARTIALMETALAREA 2.7828 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5514 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.7282 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 110.726 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.26577 LAYER Via3 ;
  END ser_tx
  PIN ser_rx 
    ANTENNAPARTIALMETALAREA 3.6468 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4394 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 144.267 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 653.795 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.3812 LAYER Via3 ;
  END ser_rx
  PIN flash_csb 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.8356 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7602 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.4912 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 109.535 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.25869 LAYER Via3 ;
>>>>>>> Stashed changes
  END flash_csb
  PIN flash_clk 
    ANTENNADIFFAREA 3.839 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.74 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.33 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.1109 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.8441 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.40966 LAYER Via3 ;
  END flash_clk
  PIN flash_io0 
    ANTENNAPARTIALMETALAREA 0.0532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2394 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNADIFFAREA 2.92225 LAYER Metal4 ; 
<<<<<<< Updated upstream
    ANTENNAPARTIALMETALAREA 0.8112 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.708 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 189.467 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 863.204 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 11.4088 LAYER Via4 ;
  END flash_io0
  PIN flash_io1 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.1892 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3514 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 28.4763 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 161.711 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.3968 LAYER Via3 ;
  END flash_io1
  PIN flash_io2 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.3621 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 147.7 LAYER Metal3 ;
=======
    ANTENNAPARTIALMETALAREA 0.1168 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5544 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 68.5233 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 315.515 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 11.402 LAYER Via4 ;
  END flash_io0
  PIN flash_io1 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2508 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6862 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 31.9675 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 159.4 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.3914 LAYER Via3 ;
  END flash_io1
  PIN flash_io2 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2032 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4432 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.3749 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 147.873 LAYER Metal3 ;
>>>>>>> Stashed changes
    ANTENNAMAXCUTCAR 11.3879 LAYER Via3 ;
  END flash_io2
  PIN flash_io3 
    ANTENNADIFFAREA 2.92225 LAYER Metal3 ; 
<<<<<<< Updated upstream
    ANTENNAPARTIALMETALAREA 3.1676 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.283 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 62.647 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 288.841 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.393 LAYER Via3 ;
=======
    ANTENNAPARTIALMETALAREA 3.1812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4018 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.249975 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 40.1335 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 187.761 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.3914 LAYER Via3 ;
>>>>>>> Stashed changes
  END flash_io3
END et4351

END LIBRARY
